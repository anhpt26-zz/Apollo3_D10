<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Apollo3_D10.ewp</path>
    </project>
    <batchBuild />
</workspace>
