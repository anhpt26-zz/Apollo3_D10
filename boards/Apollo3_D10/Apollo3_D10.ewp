# IAR project Apollo3_D10.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMA3B2KK-KBR AmbiqMicro AMA3B2KK-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; AM_PART_APOLLO3P; AM_DEBUG_PRINTF; AM_FREERTOS; AM_PACKAGE_BGA; AM_UTIL_FAULTISR_PRINT
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: source; ..\..; ..\..\CMSIS\AmbiqMicro\Include; ..\..\CMSIS\ARM\Include; ..\..\devices; ..\..\mcu\apollo3p; ..\..\mcu\apollo3p\hal; ..\..\mcu\apollo3p\regs; ..\..\third_party\FreeRTOSv10.1.1\Source\include; ..\..\third_party\FreeRTOSv10.1.1\Source\portable\IAR\AMapollo2; ..\apollo3p_evb\bsp; ..\..\utils
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: source; ..\..; ..\..\CMSIS\AmbiqMicro\Include; ..\..\CMSIS\ARM\Include; ..\..\devices; ..\..\mcu\apollo3p; ..\..\mcu\apollo3p\hal; ..\..\mcu\apollo3p\regs; ..\..\third_party\FreeRTOSv10.1.1\Source\include; ..\..\third_party\FreeRTOSv10.1.1\Source\portable\IAR\AMapollo2; ..\..\utils
  OBJCOPY.OOCOutputFile: Apollo3_D10.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: linker_script.icf
  ILINK.IlinkAdditionalLibs: ..\apollo3p_evb\bsp\iar\bin\libam_bsp.a; ..\..\mcu\apollo3p\hal\iar\bin\libam_hal.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group device
    ../../devices/: am_devices_button.c am_devices_led.c
  group source
    source/: led_task.c main.c rtos.c startup_iar.c
  group third_party/FreeRTOS
    ../../third_party/FreeRTOSv10.1.1/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../third_party/FreeRTOSv10.1.1/Source/portable/MemMang/: heap_2.c
    ../../third_party/FreeRTOSv10.1.1/Source/portable/IAR/AMapollo2/: port.c portasm.s
  group utils
    ../../utils/: am_util_debug.c am_util_delay.c am_util_faultisr.c am_util_stdio.c
